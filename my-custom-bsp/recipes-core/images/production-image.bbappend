include industrial-pc.inc
